Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: fa5c13a7-955c-47ed-b152-3127b0a1538b, NumberOfSaves: 1]
File name: 0001
Time: 2026-09-10T21:50:32+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11153610_CH_KM7667FL:26766770_CH_11153610_KM7667FL, (2)
In: Default
Type - Material: z_Miele_Design_CLST, z_Miele_Connection_Electric, <Unnamed>, z_Miele_Design_Glass Black, Default
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 620 mm; Height: 51 mm; Depth: 520 mm
Pset_BuildingElementProxyCommon - Reference: 26766770_CH_11153610_KM7667FL; sets with these values: 2
